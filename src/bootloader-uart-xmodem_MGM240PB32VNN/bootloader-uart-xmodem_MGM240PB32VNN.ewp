# IAR project bootloader-uart-xmodem_MGM240PB32VNN.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: MGM240PB32VNN SiliconLaboratories MGM240PB32VNN
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: MGM240PB32VNN=1; SE_MANAGER_CONFIG_FILE="btl_aes_ctr_stream_block_cfg.h"; BOOTLOADER_ENABLE=1; BOOTLOADER_SECOND_STAGE=1; SL_RAMFUNC_DISABLE=1; __START=main; __STARTUP_CLEAR_BSS=1; BTL_GPIO_ACTIVATION=1; BTL_UART_ENABLE=1; BOOTLOADER_SUPPORT_COMMUNICATION=1; SL_COMPONENT_CATALOG_PRESENT=1; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; MBEDTLS_PSA_CRYPTO_CLIENT=1; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_TRUSTZONE_SECURE=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse; --diag_suppress Pa082
  ICCARM.CCIncludePath2: $FILE_DIR$; config; autogen; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\Device\SiliconLabs\MGM24\Include; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\bootloader; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\bootloader\debug; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\bootloader\gpio\gpio-activation; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\bootloader\parser; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\bootloader\api; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\bootloader\security; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\bootloader\driver; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\bootloader\communication; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\bootloader\communication\xmodem-parser; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\CMSIS\Core\Include; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\emlib\inc; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\common\inc; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\security\sl_component\sl_mbedtls_support\config; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\security\sl_component\sl_mbedtls_support\config\preset; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\security\sl_component\sl_mbedtls_support\inc; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\util\third_party\mbedtls\include; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\util\third_party\mbedtls\library; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\security\sl_component\sl_psa_driver\inc; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\security\sl_component\se_manager\inc; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\security\sl_component\se_manager\src; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\util\silicon_labs\silabs_core\memory_manager; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\util\third_party\trusted-firmware-m\lib\fih\inc; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\util\third_party\trusted-firmware-m\platform\include; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\common\toolchain\inc; ..\..\..\SimplicityStudio\SDKs\gecko_sdk\platform\service\udelay\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bootloader-uart-xmodem_MGM240PB32VNN.s37
  ILINK.IlinkOutputFile: bootloader-uart-xmodem_MGM240PB32VNN.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: bootloader-uart-xmodem_MGM240PB32VNN.ipcf
