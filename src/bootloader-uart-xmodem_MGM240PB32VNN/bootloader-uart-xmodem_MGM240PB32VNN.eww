<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <!-- Automatically generated by Silicon Labs. -->
    <batchBuild />
    <project>
        <path>$WS_DIR$\bootloader-uart-xmodem_MGM240PB32VNN.ewp</path>
    </project>
</workspace>
